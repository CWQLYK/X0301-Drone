# Keil uVision project X0301.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: X0301 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\Lib\inc;.\Lib\src;.\StartUp;.\USER;.\CONFIG;.\HARDWARE;.\MATH;.\HAL
  asm define: SYSCLK_FREQ_72MHz
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group library
    ./Lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group StartUp
    ./StartUp/: AppIncludes.h core_cm3.c core_cm3.h startup_stm32f10x_md.s stm32f10x.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c system_stm32f10x.h
  group USER
    ./USER/: main.c delay.c scheduler.c ALL_DEFINE.h ALL_DATA.h INIT.c IWDG.c
  group HARDWARE
    ./HARDWARE/: LED.c MPU6050.c NRF24L01.c
  group CONFIG
    ./CONFIG/: USART1.c I2C_SoftWare.c I2C_HardWare.c ADC.c SPI.c
  group MATH
    ./MATH/: kalman.c filter.c imu.c pid.c myMath.c
  group HAL
    ./HAL/: Attitude_Process.c Attitude_Process.h Control.c Control.h
